# Keil uVision project prime numer(0 to 999).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: prime numer(0 to 999) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../C code/: prime number(0 to 999).c
